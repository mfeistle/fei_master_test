# Keil uVision project sm_test_fw_sm.uvproj, settings and files
target release (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sm_test_fw_sm_release +hex
  BeforeMake: ..\..\..\..\environment\scripts\git\git_pattern.bat
  AfterMake: fromelf --bin --output .\release\sm_test_fw_sm_release.bin .\release\sm_test_fw_sm_release.axf
  c flags: Optim=4
  c define: STM32F10X_MD_VL,TB_12K
  c include: .\;..\..\..\stm32f10x_stdperiph_lib\modules\v3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\regbus\modules
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: system_stm32f10x.c startup_stm32f10x_md_vl.s
    ../../../stm32f10x_stdperiph_lib/modules/v3.5.0/Libraries//CMSIS/CM3/CoreSupport/: core_cm3.c
  group Code
    ./: init.c main.c stm32f10x_it.c dmx_control.c RS_control.c dali.c History.c eeprom.c modbus_master.c testprocedures.c AAWmodule.c watch.c flashsetup.c KNXinterface.c SensodimController.c SliderController.c Lampcontroller.c OutputController.c
  group Library
    ../../../stm32f10x_stdperiph_lib/modules/v3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
